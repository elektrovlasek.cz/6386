Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-06-25T11:21:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 25 11:21:30 2020 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{CC63CDB7-CE9D-4256-8425-ED9AA26EA869}\ifc * Database version: 5507 * Database creation date: Thu Jun 25 11:21:29 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 25 11:21:29 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 25 11:21:29 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21526062_OE1_11479820_G5260SCVi_ED, 11479820_OE1_G5260SCVi_ED:21526062_OE1_11479820_G5260SCVi_ED:208199
In: Level 1
Type - Material: z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21526062_OE1_11479820_G5260SCVi_ED
Pset_ManufacturerTypeInformation - Manufacturer: Miele
